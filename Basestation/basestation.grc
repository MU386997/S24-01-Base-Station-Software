options:
  parameters:
    author: caleb
    generate_options: no_gui
    id: basestation
    output_language: python
    title: PLB Basestation
  states: {}

blocks:
- name: ack_port
  id: variable
  parameters:
    value: '8081'
  states: {}
- name: data_port
  id: variable
  parameters:
    value: '8080'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '915000000'
  states: {}
- name: listen_address
  id: variable
  parameters:
    value: '''::'''
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    log_level: debug
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '3'
    type: byte
  states: {}
- name: lora_rx_0
  id: lora_rx
  parameters:
    bw: '125000'
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[False,False]'
    samp_rate: samp_rate
    sf: '7'
    soft_decoding: 'True'
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '8080'
    type: byte
  states: {}
- name: network_tcp_source_0
  id: network_tcp_source
  parameters:
    addr: listen_address
    port: ack_port
    server: 'True'
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq
    gain0: '30'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_stream_to_tagged_stream_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [lora_rx_0, '0', network_tcp_sink_0, '0']
- [network_tcp_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, print]
- [uhd_usrp_source_0, '0', lora_rx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
