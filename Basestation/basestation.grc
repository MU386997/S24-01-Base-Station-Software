options:
  parameters:
    author: caleb
    generate_options: qt_gui
    id: plb
    output_language: python
    title: Personal Locator Beacon
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '915000000'
  states: {}
- name: port
  id: variable
  parameters:
    value: '8080'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: lora_rx_0
  id: lora_rx
  parameters:
    bw: '125000'
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[False,True]'
    samp_rate: samp_rate
    sf: '7'
    soft_decoding: 'True'
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '8080'
    type: byte
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '500000'
    fc: freq
    fftsize: '1024'
    type: complex
    wintype: window.WIN_RECTANGULAR
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq
    gain0: '30'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [lora_rx_0, '0', network_tcp_sink_0, '0']
- [uhd_usrp_source_0, '0', lora_rx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
