options:
  parameters:
    author: caleb
    generate_options: no_gui
    id: basestation
    output_language: python
    title: PLB Basestation
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: data_port
  id: variable
  parameters:
    value: '8080'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '915000000'
  states: {}
- name: listen_address
  id: variable
  parameters:
    value: '''::'''
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '20'
    type: byte
  states: {}
- name: lora_rx_0
  id: lora_rx
  parameters:
    bw: bandwidth
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[False,False]'
    samp_rate: samp_rate
    sf: '7'
    soft_decoding: 'True'
  states: {}
- name: lora_tx_0
  id: lora_tx
  parameters:
    bw: bandwidth
    cr: '1'
    frame_zero_padd: '1280'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    samp_rate: samp_rate
    sf: '7'
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '8080'
    type: byte
  states: {}
- name: pdu_pdu_lambda_0
  id: pdu_pdu_lambda
  parameters:
    fn: ' lambda x: pmt.intern(str("").join([chr(x) for x in (pmt.u8vector_elements(pmt.cdr(x)))]))'
    metadict: Raw Message
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: satellites_pdu_head_tail_0
  id: satellites_pdu_head_tail
  parameters:
    mode: '3'
    num: '4'
  states: {}
- name: satellites_pdu_head_tail_1
  id: satellites_pdu_head_tail
  parameters:
    mode: '0'
    num: '3'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: bandwidth
    center_freq0: freq
    gain0: '30'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: freq
    gain0: '30'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_stream_to_tagged_stream_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [lora_rx_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [lora_rx_0, '0', network_tcp_sink_0, '0']
- [lora_tx_0, '0', uhd_usrp_sink_0, '0']
- [pdu_pdu_lambda_0, pdu, blocks_message_debug_0, print]
- [pdu_pdu_lambda_0, pdu, lora_tx_0, in]
- [pdu_tagged_stream_to_pdu_0, pdus, satellites_pdu_head_tail_0, in]
- [satellites_pdu_head_tail_0, out, satellites_pdu_head_tail_1, in]
- [satellites_pdu_head_tail_1, out, pdu_pdu_lambda_0, pdu]
- [uhd_usrp_source_0, '0', lora_rx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
