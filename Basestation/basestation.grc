options:
  parameters:
    author: caleb
    generate_options: no_gui
    id: basestation
    output_language: python
    title: PLB Basestation
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '915000000'
  states: {}
- name: port
  id: variable
  parameters:
    value: '8080'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '10000'
  states: {}
- name: lora_rx_0
  id: lora_rx
  parameters:
    bw: '125000'
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[False,False]'
    samp_rate: samp_rate
    sf: '7'
    soft_decoding: 'True'
  states: {}
- name: lora_tx_0
  id: lora_tx
  parameters:
    bw: '125000'
    cr: '1'
    frame_zero_padd: '1280'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    samp_rate: samp_rate
    sf: '7'
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '8080'
    type: byte
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq
    gain0: '30'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq
    gain0: '30'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_message_strobe_0, strobe, lora_tx_0, in]
- [lora_rx_0, '0', network_tcp_sink_0, '0']
- [lora_rx_0, out, blocks_message_debug_0, print]
- [lora_tx_0, '0', uhd_usrp_sink_0, '0']
- [uhd_usrp_source_0, '0', lora_rx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
