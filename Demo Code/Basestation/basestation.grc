options:
  parameters:
    author: caleb
    generate_options: no_gui
    id: basestation
    output_language: python
    title: PLB Basestation
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: data_port
  id: variable
  parameters:
    value: '8080'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '915000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: lora_rx_0
  id: lora_rx
  parameters:
    bw: bandwidth
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[False,False]'
    samp_rate: samp_rate
    sf: '7'
    soft_decoding: 'True'
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: data_port
    type: byte
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq
    rx_agc0: Enabled
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [lora_rx_0, '0', network_tcp_sink_0, '0']
- [uhd_usrp_source_0, '0', lora_rx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
