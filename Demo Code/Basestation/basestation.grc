options:
  parameters:
    author: caleb
    generate_options: no_gui
    id: basestation
    output_language: python
    title: PLB Basestation
  states: {}

blocks:
- name: ack_len
  id: variable
  parameters:
    value: '3'
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: data_port
  id: variable
  parameters:
    value: '8080'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '915000000'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '16'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.basic_block):
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, packet_len=16, ack_len=3):
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='Generate ACK', 
                  in_sig=[np.byte],
                  out_sig=[np.byte]
              )
              self.packet_len = packet_len
              self.ack_len = ack_len
              self.message_port_register_out(pmt.intern('ack_out'))

          def general_work(self, input_items, output_items):
              tagTuple = self.get_tags_in_window(0, 0, len(input_items[0]))
              relativeOffsetList = []
              for tag in tagTuple:
                  if (pmt.to_python(tag.key) == "frame_info" and pmt.to_python(tag.value)["pay_len"] == self.packet_len):
                      relativeOffsetList.append(tag.offset - self.nitems_read(0))
              relativeOffsetList.sort()

              print(relativeOffsetList)

              return 0
    ack_len: ack_len
    packet_len: packet_len
  states: {}
- name: lora_rx_0
  id: lora_rx
  parameters:
    bw: bandwidth
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[False,False]'
    samp_rate: samp_rate
    sf: '7'
    soft_decoding: 'True'
  states: {}
- name: lora_tx_0
  id: lora_tx
  parameters:
    bw: bandwidth
    cr: '1'
    frame_zero_padd: '1280'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    samp_rate: samp_rate
    sf: '7'
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: data_port
    type: byte
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq
    gain0: '30'
    len_tag_name: '"frame_len"'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq
    rx_agc0: Enabled
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [epy_block_0, '0', network_tcp_sink_0, '0']
- [epy_block_0, ack_out, lora_tx_0, in]
- [lora_rx_0, '0', epy_block_0, '0']
- [lora_tx_0, '0', uhd_usrp_sink_0, '0']
- [uhd_usrp_source_0, '0', lora_rx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
